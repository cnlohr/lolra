options:
  parameters:
    generate_options: qt_gui
    id: testloradec
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FFTSIZE
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: FFTSIZE
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters:
    vlen: FFTSIZE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: FFTSIZE
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.txt
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/samplelog.dat
    type: float
    vlen: FFTSIZE
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/samplelog_I.dat
    type: float
    vlen: FFTSIZE
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/samplelog_Q.dat
    type: float
    vlen: FFTSIZE
  states: {}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/raw_Q.dat
    type: float
    vlen: FFTSIZE
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/raw_I.dat
    type: float
    vlen: FFTSIZE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: FFTSIZE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFTSIZE
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: FFTSIZE
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(FFTSIZE)
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: '903900000'
    impl_head: 'False'
    os_factor: '20'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'True'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0"'
    bb_gain0: '10'
    freq0: '1090000000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: '6000000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1e6
    fc: '903900000'
    fftsize: '4096'
    type: complex
    update_time: '0.001'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '4'
    freq0: 903.9e6
    gain0: '4'
    gain_mode0: 'False'
    if_gain0: '4'
    sample_rate: 3e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: 903.9e6
    samp_rate: 3e6
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_file_sink_1_0, '0']
- [blocks_complex_to_float_0, '1', blocks_file_sink_1_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_file_sink_1_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_file_sink_1_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_correctiq_0, '0', lora_sdr_frame_sync_0, '0']
- [blocks_correctiq_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_float_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [lora_sdr_crc_verif_0, msg, blocks_message_debug_0, print]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, '1', blocks_file_sink_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', lora_sdr_frame_sync_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', lora_sdr_frame_sync_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
